# IAR project R5F10BMG.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R5F10BMG RL78 - R5F10BMG
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: Source\applilet3_src; Source\RTOS; Source\RTOS\include; Source\RTOS\portable; Source\RTOS\portable\IAR; Source\RTOS\portable\MemMang
  OBJCOPY.OOCOutputFile: R5F10BMG.srec
  ILINK.IlinkOutputFile: R5F10BMG.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: Source\applilet3_src\lnkr5f10bmg.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenCodeModel: 0
  ICCRL78.CCDefines: NDEBUG
  ILINK.IlinkIcfFile: applilet3_src\lnkr5f10bmg.icf
  group Source/applilet3_src
    Source/applilet3_src/: r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c r_main.c r_systeminit.c
  group Source/RTOS
    Source/RTOS/: event_groups.c list.c queue.c tasks.c
  group Source/RTOS/include
    Source/RTOS/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h task.h timers.h
  group Source/RTOS/portable/IAR
    Source/RTOS/portable/IAR/: Core.c interrupt.asm port.c portmacro.h
  group Source/RTOS/portable/MemMang
    Source/RTOS/portable/MemMang/: heap_1.c
