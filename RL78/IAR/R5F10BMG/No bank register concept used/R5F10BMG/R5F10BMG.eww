<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\R5F10BMG.ewp</path>
    </project>
    <batchBuild />
</workspace>
